# Keil uVision project Project1_F103.uvprojx, settings and files
target Project1_F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project1_F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../Project1_SharedCore
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group GBT/Common
    ../../Project1_SharedCore/common/: gbt_types.c
  group GBT/Protocol
    ../../Project1_SharedCore/protocol/: gbt_ring.c gbt_outbox.c gbt_timer.c gbt_id.c gbt_codec.c gbt_bits.c gbt_codec_ext.c gbt_tp.c gbt_safety.c gbt_charger_sm.c gbt_vehicle_sm.c gbt_node.c
  group GBT/App
    ../../Project1_SharedCore/app/: gbt_integration.c sim_plant.c battery_model.c
  group GBT/Port
    ../../Project1_SharedCore/ports/common/: gbt_spsc.c
    ../../Project1_SharedCore/ports/stm32/f103/: port_f103.c
  group Diag/StackPaint
    ./: stack_paint_f103.s
software components: CMSIS:CORE 4.3.0
